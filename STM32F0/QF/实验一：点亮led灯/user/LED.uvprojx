# Keil uVision project LED.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F030C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: LED
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F0XX,
  c include: ..\user;..\drive;..\stm32f0;..\lib\STM32F0xx_StdPeriph_Driver\inc;..\lib\STM32F0xx_StdPeriph_Driver\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group user
    ./: main.c
  group drive
    ../drive/: led.c
  group lib
    ../lib/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c
  group ::Device
    RTE/Device/STM32F030C8/: startup_stm32f030x8.s system_stm32f0xx.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
