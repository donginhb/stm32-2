# Keil uVision project ld3320.uvproj, settings and files
target ld3320 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32_FD_SDCard-SDIO +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210E_EVAL
  c include: .\CM3;.\FWlib\inc;.\FWlib\SRC;.\IR01F_Drive
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    ./: main.c stm32f10x_it.c
    ./CM3/: core_cm3.c system_stm32f10x.c
    ./startup/: startup_stm32f10x_hd.s
    ./IR01F_Drive/: IR01F_IC_ Data_Inout _Driver.c IR01F_IC_ Driver.c
  group stm32f10x
    ./FWlib/SRC/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
target Ram (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32_FD_SDCard-SDIO +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210E_EVAL
  c include: .\FWlib\inc;.\user;.\fatfs;.\fatfs;.\CM3;.\ld330_src;.\lcd;.\startup;.\usb_user;.\user;.\FWlib\STM32_USB-FS-Device_Driver\inc;.\sd_card;.\;.\key
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x9000
  memory RVCT9: RAM 0x20009000 size 0x6000
