# Keil uVision project Project.uvproj, settings and files
target Project (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Project +hex
  c flags: Optim=1
  c define: STM32F0XX,USE_STDPERIPH_DRIVER
  c include: ..\User;..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\Arduino_App;..\..\Libraries\Arduino\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Arduino_App
    ../Arduino_App/: loop.c setup.c utilities.c
  group User
    ../User/: main.c stm32f0xx_it.c
  group StdPeriph_Driver
    ../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_rcc.c stm32f0xx_gpio.c stm32f0xx_adc.c stm32f0xx_exti.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c
  group Arduino_Library
    ../../Libraries/Arduino/src/: gpio.c serial.c spi.c
  group Startup
    ../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
  group CMSIS
    ../User/: system_stm32f0xx.c
