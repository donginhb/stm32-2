# Keil uVision project YBDZ_STM32_DEMO.uvproj, settings and files
target YBDZ_STM32_DEMO (ARM-ADS)
  device: STM32F050C4 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: YBDZ_STM32F030 +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: ..\SRC;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\ST\STM32F0xx\Include;..\Libraries\STM32F0xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group User
    ../SRC/: main.c stm32f0xx_it.c system_stm32f0xx.c startup_stm32f0xx.s
  group STM32F0xx_StdPeriph_Driver
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_rcc.c stm32f0xx_misc.c stm32f0xx_gpio.c stm32f0xx_syscfg.c stm32f0xx_exti.c
