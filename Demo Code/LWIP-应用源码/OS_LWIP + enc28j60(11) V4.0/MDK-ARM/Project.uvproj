# Keil uVision project Project.uvproj, settings and files
target Multi Media Development Board V1.0 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1 OneElfS=1
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\USER;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\USER\RTC;..\USER\LWIP\lwip-1.4.0.rc1\src\include;..\USER\LWIP;..\USER\LWIP\lwip-1.4.0.rc1\src\include\ipv4;..\USER\LWIP\enc28j60;..\USER\LWIP\lwip-1.4.0.rc1\src\include\lwip;..\USER\LWIP\lwip-1.4.0.rc1\src\include\netif;..\USER\LWIP\ARCH;..\USER\LWIP\net
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../USER/: main.c stm32f10x_it.c stm32f10x_conf.h
    ../USER/RTC/: RTC_Time.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c misc.c stm32f10x_pwr.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../USER/: system_stm32f10x.c
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group \src\core
    ../USER/LWIP/lwip-1.4.0.rc1/src/core/: init.c mem.c memp.c netif.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c dhcp.c dns.c pbuf.c raw.c def.c
  group \src\api
    ../USER/LWIP/lwip-1.4.0.rc1/src/api/: sockets.c api_lib.c err.c netbuf.c netdb.c netifapi.c tcpip.c api_msg.c
  group \Lwip\Arch
    ../USER/LWIP/ARCH/: sys_arch.C
  group \src\core\ipv4
    ../USER/LWIP/lwip-1.4.0.rc1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group \src\core\snmp
    ../USER/LWIP/lwip-1.4.0.rc1/src/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
  group \src\netif
    ../USER/LWIP/lwip-1.4.0.rc1/src/netif/: etharp.c slipif.c
  group \LWIP\enc28j60
    ../USER/LWIP/enc28j60/: SPI.C ENC28J60.C
    ../USER/LWIP/: ethernetif.c Http_107.c HelloWorld.c LwIPEntry.c WEB_HTTP.c
  group readme
    ../: readme.txt readme2.txt
