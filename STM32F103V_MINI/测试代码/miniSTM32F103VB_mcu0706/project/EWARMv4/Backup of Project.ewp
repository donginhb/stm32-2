# IAR project Backup of Project.ewp, settings and files
configuration BOOT_RAM (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl7mptnnl8f.h
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCDefines: VECT_TAB_RAM
  ICCARM.CCIncludePath2: ..\; ..\inc; ..\..\FWLib\library\inc; ..\..\USBLib\library\inc; ..\..\USBLib\Virtual_COM_Port\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnkarm_ram.xcl
configuration BOOT_FLASH (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: VECT_TAB_FLASH
  ICCARM.CCIncludePath2: ..\; ..\..\FWLib\library\inc; ..\..\USBLib\library\inc; ..\..\USBLib\Virtual_COM_Port\inc; ..\inc
  XLINK.XclFile: lnkarm_flash.xcl
  group EWARM
    ./: cortexm3_macro.s stm32f10x_vector.c
  group FWLib
    ../../FWLib/library/src/: stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c
  group User
    ../src/: main.c
  group User/com
    ../src/com/: com_app.c com_pc_com.c uart_driver.c
  group User/comm
    ../src/comm/: buz.c delay.c key.c led103.c load_paper.c mp_out.c paper_mea.c printer_mem.c stm32f10x_it.c stm32f10x_Timebase.c
  group User/fpga
    ../src/fpga/: fpga_driver.c
  group User/LCM
    ../src/lcm/: lcm_driver.c lcm_menu.c lcm_zikulib.c
  group User/MC
    ../src/mc/: MC_Globals.c MC_PID_regulate.c MC_servo.c MC_servo_pos_ctr.c MC_servo_speed_ctr.c stm32f10x_encoder.c
  group User/spi
    ../src/spi_flash/: spi_flash.c
  group User/Stepper
    ../src/stepper/: stepper.c stepper_A3979.c stepper_TB6560.c
