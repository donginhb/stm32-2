# Keil uVision project USB.uvproj, settings and files
target USB_TEST (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: USB_TEST +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: VECT_TAB_FLASH
  c include: .\usb_library\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start_up
    ./: STM32F10x.s
  group Source
    ./: main.c usb_desc.c usb_istr.c usb_prop.c usb_pwr.c hw_config.c
  group Interrupt
    ./: stm32f10x_it.c
  group Library
    E:/Boards/M3/okstm32v100/示例程序/common/: STM32F10xR.LIB
  group USBLib
    ./usb_library/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group Document
    ./: FLASH.ini
