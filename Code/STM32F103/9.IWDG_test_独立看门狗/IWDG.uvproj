# Keil uVision project IWDG.uvproj, settings and files
target IWDG (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: IWDG +hex
  c flags: Optim=4 OneElfS=1
  c include: ..\..\library\inc;..\..\library\src;..\uvsion
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup Code
    ./: STM32F10x.s
  group Source Code
    ./: main.c
  group Interrupt
    ./: stm32f10x_it.c
  group library
    E:/Boards/M3/okstm32v100/示例程序/common/: STM32F10xR.lib
