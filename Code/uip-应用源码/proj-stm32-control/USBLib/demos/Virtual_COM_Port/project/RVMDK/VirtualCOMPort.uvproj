# Keil uVision project VirtualCOMPort.uvproj, settings and files
target BOOT_FLASH (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: VirtualCOMPort +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: VECT_TAB_FLASH
  c include: ..\..\include;..\..\..\..\library\inc;..\..\..\..\..\FWLib\library\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application files
    ../../source/: hw_config.c main.c stm32f10x_it.c usb_desc.c usb_istr.c usb_prop.c usb_pwr.c usb_endp.c protocol.c DES.C
  group USBLib
    ../../../../library/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group FWLib
    ../../../../../FWLib/library/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_flash.c stm32f10x_usart.c
  group RVMDK
    ./: stm32f10x_vector.s cortexm3_macro.s
