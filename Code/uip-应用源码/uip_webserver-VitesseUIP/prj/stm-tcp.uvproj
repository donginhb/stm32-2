# Keil uVision project stm-tcp.uvproj, settings and files
target stm-tcp (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm-tcp +hex
  c flags: Optim=1
  c include: ..\src;..\src\stdlib;..\src\enc28j60;..\src\uip1.0;..\src\uip1.0\uip;..\src\uip1.0\lib;..\src\uip1.0\apps\dhcpc;..\src\uip1.0\unix;..\src\webserver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group startup
    ../src/stdlib/StartUp/: startup_stm32f10x_md.s
  group stdlib
    ../src/stdlib/: stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c system_stm32f10x.c core_cm3.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c
  group uip1.0
    ../src/uip1.0/uip/: uip.c uip_arp.c uip_timer.c
  group netchip
    ../src/enc28j60/: enc28j60.c spi_enc28j60.c
  group module
    ../src/: delay.c exti.c global.c gpio.c platform_init.c stm32f10x_it.c timer.c usart.c usart_app.c
  group app
    ../src/: main.c
    ../src/uip1.0/unix/: clock-arch.c tapdev.c
    ../src/uip1.0/apps/dhcpc/: dhcpc.c
  group webserver
    ../src/webserver/: webhnd.c webpost.c webvar.c fs.c miscfun.c httpd.c
  group webpages
    ../src/webpages/: index.c password.c httpstat.c duplicate.c left.c passwordConfirmation.c sys.c top.c upload.c uploaddone.c bg.c postdemo.c get.c
