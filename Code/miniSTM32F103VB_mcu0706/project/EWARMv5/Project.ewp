# IAR project Project.ewp, settings and files
configuration BOOT_RAM (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCDefines: VECT_TAB_RAM
  ICCARM.CCIncludePath2: ..\; ..\inc; ..\..\FWLib\library\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkOutputFile: STM3210E-EVAL.out
  ILINK.IlinkIcfFile: stm32f10x_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration BOOT_FLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  ICCARM.CCDefines: VECT_TAB_FLASH
  ICCARM.CCIncludePath2: ..\; ..\..\library\inc
  ILINK.IlinkIcfFile: STM32F10x_FLASH.icf
  group Doc
    ./: readme.txt
  group EWARMv5
    ./: cortexm3_macro.s stm32f10x_vector.c
  group FWLib
    ../../FWLib/library/src/: stm32f10x_adc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c
  group User
    ../src/: main.c
  group User/com
    ../src/com/: com_pc_com.c uart_driver.c
  group User/comm
    ../src/comm/: delay.c led103.c printer_mem.c stm32f10x_it.c stm32f10x_Timebase.c
  group User/lcm
    ../src/lcm/: lcm_menu.c lcm_zikulib.c
